# IAR project kuroBox.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORTEX_USE_FPU=TRUE
  ICCARM.CCIncludePath2: ..\src; ..\src\cfg; ..\..\chibios_trunk\os\kernel\include; ..\..\chibios_trunk\os\ports\common\ARMCMx; ..\..\chibios_trunk\os\ports\common\ARMCMx\CMSIS\include; ..\..\chibios_trunk\os\ports\IAR\ARMCMx; ..\..\chibios_trunk\os\ports\IAR\ARMCMx\STM32F4xx; ..\..\chibios_trunk\os\hal\include; ..\..\chibios_trunk\os\hal\platforms\STM32; ..\..\chibios_trunk\os\hal\platforms\STM32\DMAv1; ..\..\chibios_trunk\os\hal\platforms\STM32\I2Cv1; ..\..\chibios_trunk\os\hal\platforms\STM32\GPIOv2; ..\..\chibios_trunk\os\hal\platforms\STM32\SPIv1; ..\..\chibios_trunk\os\hal\platforms\STM32\RTCv2; ..\..\chibios_trunk\os\hal\platforms\STM32\USBv1; ..\..\chibios_trunk\os\hal\platforms\STM32\USARTv1; ..\..\chibios_trunk\os\hal\platforms\STM32F4xx; ..\..\chibios_trunk\os\various; ..\..\libltc\src\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORTEX_USE_FPU=TRUE
  AARM.AUserIncludes: ..; ..\src; ..\..\chibios_trunk\os\ports\IAR\ARMCMx\STM32F4xx
  OBJCOPY.OOCOutputFile: kuroBox.bin
  ILINK.IlinkOutputFile: kuroBox.out
  ILINK.IlinkIcfFile: kuroBox.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CORTEX_USE_FPU=TRUE
  ICCARM.CCIncludePath2: ..\src; ..\..\chibios_trunk\os\kernel\include; ..\..\chibios_trunk\os\ports\common\ARMCMx; ..\..\chibios_trunk\os\ports\common\ARMCMx\CMSIS\include; ..\..\chibios_trunk\os\ports\IAR\ARMCMx; ..\..\chibios_trunk\os\ports\IAR\ARMCMx\STM32F4xx; ..\..\chibios_trunk\os\hal\include; ..\..\chibios_trunk\os\hal\platforms\STM32; ..\..\chibios_trunk\os\hal\platforms\STM32\DMAv1; ..\..\chibios_trunk\os\hal\platforms\STM32\I2Cv1; ..\..\chibios_trunk\os\hal\platforms\STM32\GPIOv2; ..\..\chibios_trunk\os\hal\platforms\STM32\SPIv1; ..\..\chibios_trunk\os\hal\platforms\STM32\RTCv2; ..\..\chibios_trunk\os\hal\platforms\STM32\USBv1; ..\..\chibios_trunk\os\hal\platforms\STM32\USARTv1; ..\..\chibios_trunk\os\hal\platforms\STM32F4xx; ..\..\chibios_trunk\os\various; ..\..\libltc\src\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: kuroBox.hex
  group os/hal/include
    ../../chibios_trunk/os/hal/include/: adc.h can.h ext.h gpt.h hal.h i2c.h icu.h mac.h mii.h mmc_spi.h pal.h pwm.h rtc.h sdc.h serial.h serial_usb.h spi.h uart.h usb.h usb_cdc.h
  group os/hal/src
    ../../chibios_trunk/os/hal/src/: adc.c can.c ext.c gpt.c hal.c i2c.c icu.c mac.c mmc_spi.c mmcsd.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c tm.c uart.c usb.c
  group os/kernel/include
    ../../chibios_trunk/os/kernel/include/: ch.h chcond.h chdebug.h chdynamic.h chevents.h chheap.h chinline.h chlists.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstreams.h chsys.h chthreads.h chvt.h
  group os/kernel/src
    ../../chibios_trunk/os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
  group os/platform
    ../../chibios_trunk/os/hal/platforms/STM32F4xx/: adc_lld.c adc_lld.h hal_lld.c hal_lld.h stm32_dma.c stm32_dma.h stm32_rcc.h stm32f4xx.h
    ../../chibios_trunk/os/hal/platforms/STM32/: ext_lld.c ext_lld.h gpt_lld.c gpt_lld.h icu_lld.c icu_lld.h pwm_lld.c pwm_lld.h sdc_lld.c sdc_lld.h
    ../../chibios_trunk/os/hal/platforms/STM32/I2Cv1/: i2c_lld.c i2c_lld.h
    ../../chibios_trunk/os/hal/platforms/STM32/GPIOv2/: pal_lld.c pal_lld.h
    ../../chibios_trunk/os/hal/platforms/STM32/RTCv2/: rtc_lld.c rtc_lld.h
    ../../chibios_trunk/os/hal/platforms/STM32/USARTv1/: serial_lld.c serial_lld.h
    ../../chibios_trunk/os/hal/platforms/STM32/SPIv1/: spi_lld.c spi_lld.h
  group os/port
    ../../chibios_trunk/os/ports/IAR/ARMCMx/: chcore.c chcore.h chcore_v7m.c chcore_v7m.h chcoreasm_v7m.s chtypes.h cstartup.s
    ../../chibios_trunk/os/ports/common/ARMCMx/: nvic.c nvic.h
  group os/port/STM32F4xx
    ../../chibios_trunk/os/ports/IAR/ARMCMx/STM32F4xx/: cmparams.h vectors.s
  group os/various
    ../../chibios_trunk/os/various/: chprintf.c chprintf.h chrtclib.c chrtclib.h memstreams.c memstreams.h
  group src
    ../src/: chconf.h diskio.h fatfs_diskio.c fatfsWrapper.c fatfsWrapper.h fatfsWrapperConfig.h ff.c ff.h ffconf.h glcdfont.c halconf.h integer.h kb_callbacks.c kb_callbacks.h kb_logger.c kb_logger.h kb_screen.c kb_screen.h kb_time.c kb_time.h main.c mcuconf.h nanibox_util.h spiEEPROM.c spiEEPROM.h ST7565.c ST7565.h
  group src/cfg
    ../src/cfg/: board.c board.h
  group src/ltc
    ../../libltc/src/: decoder.c decoder.h encoder.c encoder.h ltc.c ltc.h ltc_conf.h timecode.c
